# Keil uVision project MOV.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32F446RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MOV
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./: main.s
software components: CMSIS:CORE 6.0.0, Device:STM32Cube LL:ADC 1.8.1, Device:STM32Cube LL:Common 1.8.1, Device:STM32Cube LL:DAC 1.8.1, Device:STM32Cube LL:EXTI 1.8.1, Device:STM32Cube LL:GPIO 1.8.1, Device:STM32Cube LL:I2C 1.8.1, Device:STM32Cube LL:PWR 1.8.1, Device:STM32Cube LL:RCC 1.8.1, Device:STM32Cube LL:SPI 1.8.1, Device:STM32Cube LL:TIM 1.8.1, Device:STM32Cube LL:USART 1.8.1, Device:STM32Cube LL:UTILS 1.8.1, Device:Startup 2.6.3
